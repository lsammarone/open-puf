v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 0 -50 50 -50 { lab=#net1}
N -0 -120 -0 -70 { lab=VDD}
N 220 -120 220 -70 { lab=VDD}
N 270 -130 270 -70 { lab=RESET}
N 220 -50 270 -50 { lab=#net2}
N 440 -120 440 -70 { lab=VDD}
N 440 -50 500 -50 { lab=#net3}
N 670 -120 670 -70 { lab=VDD}
N 670 -50 720 -50 { lab=#net4}
N 720 -130 720 -70 { lab=RESET}
N 50 -130 50 -70 { lab=RESET}
N 500 -130 500 -70 { lab=RESET}
N 940 -130 940 -70 { lab=RESET}
N 1160 -130 1160 -70 { lab=RESET}
N 1380 -130 1380 -70 { lab=RESET}
N 1600 -130 1600 -70 { lab=RESET}
N 1830 -130 1830 -70 { lab=RESET}
N 2050 -130 2050 -70 { lab=RESET}
N 2270 -130 2270 -70 { lab=RESET}
N 2490 -130 2490 -70 { lab=RESET}
N 2720 -130 2720 -70 { lab=RESET}
N 2940 -130 2940 -70 { lab=RESET}
N 3160 -130 3160 -70 { lab=RESET}
N 270 -130 270 -70 { lab=RESET}
N 890 -120 890 -70 { lab=VDD}
N 1110 -120 1110 -70 { lab=VDD}
N 1330 -120 1330 -70 { lab=VDD}
N 1550 -120 1550 -70 { lab=VDD}
N 1770 -120 1770 -70 { lab=VDD}
N 2000 -120 2000 -70 { lab=VDD}
N 2220 -120 2220 -70 { lab=VDD}
N 2440 -120 2440 -70 { lab=VDD}
N 2890 -120 2890 -70 { lab=VDD}
N 2660 -120 2660 -70 { lab=VDD}
N 3110 -120 3110 -70 { lab=VDD}
N 3330 -120 3330 -70 { lab=VDD}
N 890 -50 940 -50 { lab=#net5}
N 1110 -50 1160 -50 { lab=#net6}
N 1330 -50 1380 -50 { lab=#net7}
N 1550 -50 1600 -50 { lab=#net8}
N 2000 -50 2050 -50 { lab=#net9}
N 2220 -50 2270 -50 { lab=#net10}
N 2440 -50 2490 -50 { lab=#net11}
N 2660 -50 2720 -50 { lab=#net12}
N 2890 -50 2940 -50 { lab=#net13}
N 3110 -50 3160 -50 { lab=#net14}
N -230 -50 -170 -50 { lab=OUT}
N -230 -50 -230 90 { lab=OUT}
N -230 90 3420 90 { lab=OUT}
N 0 -30 0 30 { lab=GND}
N 220 -30 220 30 { lab=GND}
N 440 -30 440 30 { lab=GND}
N 670 -30 670 30 { lab=GND}
N 890 -30 890 30 { lab=GND}
N 1110 -30 1110 30 { lab=GND}
N 1330 -30 1330 30 { lab=GND}
N 1550 -30 1550 30 { lab=GND}
N 1770 -30 1770 30 { lab=GND}
N 2000 -30 2000 30 { lab=GND}
N 2220 -30 2220 30 { lab=GND}
N 2440 -30 2440 30 { lab=GND}
N 2660 -30 2660 30 { lab=GND}
N 2890 -30 2890 30 { lab=GND}
N 3110 -30 3110 30 { lab=GND}
N 3330 -30 3330 30 { lab=GND}
N 3110 30 3330 30 { lab=GND}
N 2890 30 3110 30 { lab=GND}
N 2660 30 2890 30 { lab=GND}
N 2440 30 2660 30 { lab=GND}
N 2220 30 2440 30 { lab=GND}
N 2000 30 2220 30 { lab=GND}
N 1770 30 2000 30 { lab=GND}
N 1550 30 1770 30 { lab=GND}
N 1330 30 1550 30 { lab=GND}
N 1110 30 1330 30 { lab=GND}
N 890 30 1110 30 { lab=GND}
N 670 30 890 30 { lab=GND}
N 440 30 670 30 { lab=GND}
N 220 30 440 30 { lab=GND}
N 0 30 220 30 { lab=GND}
N 0 -120 220 -120 { lab=VDD}
N 220 -120 440 -120 { lab=VDD}
N 440 -120 670 -120 { lab=VDD}
N 670 -120 890 -120 { lab=VDD}
N 890 -120 1110 -120 { lab=VDD}
N 1110 -120 1330 -120 { lab=VDD}
N 1330 -120 1550 -120 { lab=VDD}
N 1550 -120 1770 -120 { lab=VDD}
N 1770 -120 2000 -120 { lab=VDD}
N 2000 -120 2220 -120 { lab=VDD}
N 2220 -120 2440 -120 { lab=VDD}
N 2440 -120 2660 -120 { lab=VDD}
N 2660 -120 2890 -120 { lab=VDD}
N 2890 -120 3110 -120 { lab=VDD}
N 3110 -120 3330 -120 { lab=VDD}
N 2940 -130 3160 -130 { lab=RESET}
N 2720 -130 2940 -130 { lab=RESET}
N 2490 -130 2720 -130 { lab=RESET}
N 2270 -130 2490 -130 { lab=RESET}
N 2050 -130 2270 -130 { lab=RESET}
N 1830 -130 2050 -130 { lab=RESET}
N 1600 -130 1830 -130 { lab=RESET}
N 1380 -130 1600 -130 { lab=RESET}
N 1160 -130 1380 -130 { lab=RESET}
N 940 -130 1160 -130 { lab=RESET}
N 720 -130 940 -130 { lab=RESET}
N 500 -130 720 -130 { lab=RESET}
N 270 -130 500 -130 { lab=RESET}
N 50 -130 270 -130 { lab=RESET}
N -170 -130 50 -130 { lab=RESET}
N -170 -130 -170 -70 { lab=RESET}
N -60 -170 20 -170 { lab=GND}
N 20 -170 20 30 { lab=GND}
N -150 200 -150 220 { lab=GND}
N -150 120 -150 140 { lab=V1}
N 210 200 210 220 { lab=GND}
N 210 120 210 140 { lab=V0}
N -170 -30 -170 20 { lab=V0}
N 50 -30 50 20 { lab=V1}
N 270 -30 270 20 { lab=V0}
N 500 -30 500 20 { lab=V1}
N 720 -30 720 20 { lab=V0}
N 940 -30 940 20 { lab=V1}
N 1160 -30 1160 20 { lab=V0}
N 1380 -30 1380 20 { lab=V1}
N 1600 -30 1600 20 { lab=V0}
N 1830 -30 1830 20 { lab=V1}
N 2050 -30 2050 20 { lab=V0}
N 2270 -30 2270 20 { lab=V1}
N 2490 -30 2490 20 { lab=V0}
N 2720 -30 2720 20 { lab=V1}
N 2940 -30 2940 20 { lab=V0}
N 3160 -30 3160 20 { lab=V1}
N -170 -240 -90 -240 { lab=RESET}
N -170 -180 -170 -160 { lab=GND}
N -90 -240 -90 -130 { lab=RESET}
N 90 -180 90 -150 { lab=GND}
N 90 -240 180 -240 { lab=VDD}
N 180 -240 180 -120 { lab=VDD}
N 1770 -50 1840 -50 { lab=#net15}
N 3590 -50 3640 -50 { lab=#net16}
N 3590 -120 3590 -70 { lab=VDD}
N 3810 -120 3810 -70 { lab=VDD}
N 3860 -130 3860 -70 { lab=RESET}
N 3810 -50 3860 -50 { lab=#net17}
N 4030 -120 4030 -70 { lab=VDD}
N 4030 -50 4090 -50 { lab=#net18}
N 4260 -120 4260 -70 { lab=VDD}
N 4260 -50 4310 -50 { lab=#net19}
N 4310 -130 4310 -70 { lab=RESET}
N 3640 -130 3640 -70 { lab=RESET}
N 4090 -130 4090 -70 { lab=RESET}
N 4530 -130 4530 -70 { lab=RESET}
N 4750 -130 4750 -70 { lab=RESET}
N 4970 -130 4970 -70 { lab=RESET}
N 5190 -130 5190 -70 { lab=RESET}
N 5420 -130 5420 -70 { lab=RESET}
N 5640 -130 5640 -70 { lab=RESET}
N 5860 -130 5860 -70 { lab=RESET}
N 6080 -130 6080 -70 { lab=RESET}
N 6310 -130 6310 -70 { lab=RESET}
N 6530 -130 6530 -70 { lab=RESET}
N 6750 -130 6750 -70 { lab=RESET}
N 3860 -130 3860 -70 { lab=RESET}
N 4480 -120 4480 -70 { lab=VDD}
N 4700 -120 4700 -70 { lab=VDD}
N 4920 -120 4920 -70 { lab=VDD}
N 5140 -120 5140 -70 { lab=VDD}
N 5360 -120 5360 -70 { lab=VDD}
N 5590 -120 5590 -70 { lab=VDD}
N 5810 -120 5810 -70 { lab=VDD}
N 6030 -120 6030 -70 { lab=VDD}
N 6480 -120 6480 -70 { lab=VDD}
N 6250 -120 6250 -70 { lab=VDD}
N 6700 -120 6700 -70 { lab=VDD}
N 6920 -120 6920 -70 { lab=VDD}
N 4480 -50 4530 -50 { lab=#net20}
N 4700 -50 4750 -50 { lab=#net21}
N 4920 -50 4970 -50 { lab=#net22}
N 5140 -50 5190 -50 { lab=#net23}
N 5590 -50 5640 -50 { lab=#net24}
N 5810 -50 5860 -50 { lab=#net25}
N 6030 -50 6080 -50 { lab=#net26}
N 6250 -50 6310 -50 { lab=#net27}
N 6480 -50 6530 -50 { lab=#net28}
N 6700 -50 6750 -50 { lab=#net29}
N 6920 -50 7010 -50 { lab=OUT}
N 3360 90 7010 90 { lab=OUT}
N 7010 -50 7010 90 { lab=OUT}
N 3590 -30 3590 30 { lab=GND}
N 3810 -30 3810 30 { lab=GND}
N 4030 -30 4030 30 { lab=GND}
N 4260 -30 4260 30 { lab=GND}
N 4480 -30 4480 30 { lab=GND}
N 4700 -30 4700 30 { lab=GND}
N 4920 -30 4920 30 { lab=GND}
N 5140 -30 5140 30 { lab=GND}
N 5360 -30 5360 30 { lab=GND}
N 5590 -30 5590 30 { lab=GND}
N 5810 -30 5810 30 { lab=GND}
N 6030 -30 6030 30 { lab=GND}
N 6250 -30 6250 30 { lab=GND}
N 6480 -30 6480 30 { lab=GND}
N 6700 -30 6700 30 { lab=GND}
N 6920 -30 6920 30 { lab=GND}
N 6700 30 6920 30 { lab=GND}
N 6480 30 6700 30 { lab=GND}
N 6250 30 6480 30 { lab=GND}
N 6030 30 6250 30 { lab=GND}
N 5810 30 6030 30 { lab=GND}
N 5590 30 5810 30 { lab=GND}
N 5360 30 5590 30 { lab=GND}
N 5140 30 5360 30 { lab=GND}
N 4920 30 5140 30 { lab=GND}
N 4700 30 4920 30 { lab=GND}
N 4480 30 4700 30 { lab=GND}
N 4260 30 4480 30 { lab=GND}
N 4030 30 4260 30 { lab=GND}
N 3810 30 4030 30 { lab=GND}
N 3590 30 3810 30 { lab=GND}
N 3590 -120 3810 -120 { lab=VDD}
N 3810 -120 4030 -120 { lab=VDD}
N 4030 -120 4260 -120 { lab=VDD}
N 4260 -120 4480 -120 { lab=VDD}
N 4480 -120 4700 -120 { lab=VDD}
N 4700 -120 4920 -120 { lab=VDD}
N 4920 -120 5140 -120 { lab=VDD}
N 5140 -120 5360 -120 { lab=VDD}
N 5360 -120 5590 -120 { lab=VDD}
N 5590 -120 5810 -120 { lab=VDD}
N 5810 -120 6030 -120 { lab=VDD}
N 6030 -120 6250 -120 { lab=VDD}
N 6250 -120 6480 -120 { lab=VDD}
N 6480 -120 6700 -120 { lab=VDD}
N 6700 -120 6920 -120 { lab=VDD}
N 6530 -130 6750 -130 { lab=RESET}
N 6310 -130 6530 -130 { lab=RESET}
N 6080 -130 6310 -130 { lab=RESET}
N 5860 -130 6080 -130 { lab=RESET}
N 5640 -130 5860 -130 { lab=RESET}
N 5420 -130 5640 -130 { lab=RESET}
N 5190 -130 5420 -130 { lab=RESET}
N 4970 -130 5190 -130 { lab=RESET}
N 4750 -130 4970 -130 { lab=RESET}
N 4530 -130 4750 -130 { lab=RESET}
N 4310 -130 4530 -130 { lab=RESET}
N 4090 -130 4310 -130 { lab=RESET}
N 3860 -130 4090 -130 { lab=RESET}
N 3640 -130 3860 -130 { lab=RESET}
N 3420 -130 3640 -130 { lab=RESET}
N 3420 -130 3420 -70 { lab=RESET}
N 3420 -30 3420 20 { lab=V0}
N 3640 -30 3640 20 { lab=V1}
N 3860 -30 3860 20 { lab=V0}
N 4090 -30 4090 20 { lab=V1}
N 4310 -30 4310 20 { lab=V0}
N 4530 -30 4530 20 { lab=V1}
N 4750 -30 4750 20 { lab=V0}
N 4970 -30 4970 20 { lab=V1}
N 5190 -30 5190 20 { lab=V0}
N 5420 -30 5420 20 { lab=V1}
N 5640 -30 5640 20 { lab=V0}
N 5860 -30 5860 20 { lab=V1}
N 6080 -30 6080 20 { lab=V0}
N 6310 -30 6310 20 { lab=V1}
N 6530 -30 6530 20 { lab=V0}
N 6750 -30 6750 20 { lab=V1}
N 5360 -50 5430 -50 { lab=#net30}
N 3160 -130 3430 -130 { lab=RESET}
N 3330 30 3630 30 { lab=GND}
N 3330 -50 3430 -50 { lab=#net31}
N 3330 -120 3620 -120 { lab=VDD}
C {singlestage.sym} -20 -50 0 0 {name=x1}
C {singlestage.sym} 200 -50 0 0 {name=x2}
C {singlestage.sym} 420 -50 0 0 {name=x3}
C {singlestage.sym} 650 -50 0 0 {name=x4}
C {singlestage.sym} 870 -50 0 0 {name=x5}
C {singlestage.sym} 1090 -50 0 0 {name=x6}
C {singlestage.sym} 1310 -50 0 0 {name=x7}
C {singlestage.sym} 1530 -50 0 0 {name=x8}
C {singlestage.sym} 1750 -50 0 0 {name=x9}
C {singlestage.sym} 1980 -50 0 0 {name=x10}
C {singlestage.sym} 2200 -50 0 0 {name=x11}
C {singlestage.sym} 2420 -50 0 0 {name=x12}
C {singlestage.sym} 2640 -50 0 0 {name=x13}
C {singlestage.sym} 2870 -50 0 0 {name=x14}
C {singlestage.sym} 3090 -50 0 0 {name=x15}
C {singlestage.sym} 3310 -50 0 0 {name=x16}
C {singlestage.sym} 1750 -50 0 0 {name=x17}
C {singlestage.sym} 1980 -50 0 0 {name=x18}
C {singlestage.sym} 2200 -50 0 0 {name=x19}
C {singlestage.sym} 2420 -50 0 0 {name=x20}
C {devices/gnd.sym} -60 -170 0 0 {name=l1 lab=GND}
C {devices/vsource.sym} -150 170 0 0 {name=V1 value=1.8
*PULSE"(1.8 0 80ns 10ps 10ps 80ns 160ns)"
}
C {devices/gnd.sym} -150 220 0 0 {name=l2 lab=GND}
C {devices/vsource.sym} 210 170 0 0 {name=V2 value=0
}
C {devices/gnd.sym} 210 220 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} -150 130 0 0 {name=l4 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 210 130 0 0 {name=l6 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 3160 0 0 0 {name=l7 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 2940 0 0 0 {name=l8 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 2720 0 0 0 {name=l9 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 2490 0 0 0 {name=l11 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 2270 0 0 0 {name=l12 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 2050 0 0 0 {name=l13 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 1830 0 0 0 {name=l14 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 1600 0 0 0 {name=l15 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 1380 0 0 0 {name=l16 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 1160 0 0 0 {name=l10 sig_type=std_logic lab=V0
}
C {devices/lab_pin.sym} 940 0 0 0 {name=l18 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 720 0 0 0 {name=l19 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 500 0 0 0 {name=l20 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 270 0 0 0 {name=l21 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 50 0 0 0 {name=l22 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} -170 0 0 0 {name=l5 sig_type=std_logic lab=V0}
C {devices/gnd.sym} -170 -160 0 0 {name=l17 lab=GND}
C {devices/vsource.sym} 90 -210 0 0 {name=V3 value=1.8}
C {devices/gnd.sym} 90 -160 0 0 {name=l23 lab=GND}
C {devices/vsource.sym} -170 -210 0 0 {name=V4 value=PULSE"(1.8 0 10ns 10ps 10ps 150s 160ns)"}
C {devices/code.sym} -100 -450 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
**.lib $::SKYWATER_MODELS/sky130.lib.spice tt
.lib /farmshare/home/classes/ee/372/PDKs/open_pdks_1.0.310/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice tt_mm 
.include /farmshare/home/classes/ee/372/PDKs/open_pdks_1.0.310/sky130/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice

"
spice_ignore=false
}
C {devices/code_shown.sym} 110 -610 0 0 {name=NGSPICE
only_toplevel=true
value="
.option seed=random

.control 
let mc_runs=100
let run=1
dowhile run <= mc_runs
reset
tran 10n 100n
wrdata ~/372puf/ee372/unique/sims/32cellout_\{$&run\}.txt v(out)
let run = run +1
end

save all
.endc
"}
C {devices/lab_pin.sym} 140 -240 0 0 {name=l24 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -110 -240 0 0 {name=l25 sig_type=std_logic lab=RESET}
C {devices/lab_pin.sym} -110 90 0 0 {name=l26 sig_type=std_logic lab=OUT}
C {singlestage.sym} 3570 -50 0 0 {name=x21}
C {singlestage.sym} 3790 -50 0 0 {name=x22}
C {singlestage.sym} 4010 -50 0 0 {name=x23}
C {singlestage.sym} 4240 -50 0 0 {name=x24}
C {singlestage.sym} 4460 -50 0 0 {name=x25}
C {singlestage.sym} 4680 -50 0 0 {name=x26}
C {singlestage.sym} 4900 -50 0 0 {name=x27}
C {singlestage.sym} 5120 -50 0 0 {name=x28}
C {singlestage.sym} 5340 -50 0 0 {name=x29}
C {singlestage.sym} 5570 -50 0 0 {name=x30}
C {singlestage.sym} 5790 -50 0 0 {name=x31}
C {singlestage.sym} 6010 -50 0 0 {name=x32}
C {singlestage.sym} 6230 -50 0 0 {name=x33}
C {singlestage.sym} 6460 -50 0 0 {name=x34}
C {singlestage.sym} 6680 -50 0 0 {name=x35}
C {singlestage.sym} 6900 -50 0 0 {name=x36}
C {singlestage.sym} 5340 -50 0 0 {name=x37}
C {singlestage.sym} 5570 -50 0 0 {name=x38}
C {singlestage.sym} 5790 -50 0 0 {name=x39}
C {singlestage.sym} 6010 -50 0 0 {name=x40}
C {devices/lab_pin.sym} 6750 0 0 0 {name=l29 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 6530 0 0 0 {name=l30 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 6310 0 0 0 {name=l31 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 6080 0 0 0 {name=l32 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 5860 0 0 0 {name=l33 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 5640 0 0 0 {name=l34 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 5420 0 0 0 {name=l35 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 5190 0 0 0 {name=l36 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 4970 0 0 0 {name=l37 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 4750 0 0 0 {name=l38 sig_type=std_logic lab=V0
}
C {devices/lab_pin.sym} 4530 0 0 0 {name=l39 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 4310 0 0 0 {name=l40 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 4090 0 0 0 {name=l41 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 3860 0 0 0 {name=l42 sig_type=std_logic lab=V0}
C {devices/lab_pin.sym} 3640 0 0 0 {name=l43 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 3420 0 0 0 {name=l44 sig_type=std_logic lab=V0}
