v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 0 -50 50 -50 { lab=#net1}
N -0 -120 -0 -70 { lab=VDD}
N 220 -120 220 -70 { lab=VDD}
N 270 -130 270 -70 { lab=r1}
N 220 -50 270 -50 { lab=#net2}
N 440 -120 440 -70 { lab=VDD}
N 440 -50 500 -50 { lab=#net3}
N 670 -120 670 -70 { lab=VDD}
N 670 -50 720 -50 { lab=#net4}
N 720 -130 720 -70 { lab=r1}
N 50 -130 50 -70 { lab=r1}
N 500 -130 500 -70 { lab=r1}
N 940 -130 940 -70 { lab=r1}
N 1160 -130 1160 -70 { lab=r1}
N 1380 -130 1380 -70 { lab=r1}
N 1600 -130 1600 -70 { lab=r2}
N 1830 -130 1830 -70 { lab=r2}
N 2050 -130 2050 -70 { lab=r2}
N 2270 -130 2270 -70 { lab=r2}
N 2490 -130 2490 -70 { lab=r2}
N 2720 -130 2720 -70 { lab=r2}
N 2940 -130 2940 -70 { lab=r2}
N 3160 -130 3160 -70 { lab=r2}
N 270 -130 270 -70 { lab=r1}
N 890 -120 890 -70 { lab=VDD}
N 1110 -120 1110 -70 { lab=VDD}
N 1330 -120 1330 -70 { lab=VDD}
N 1550 -120 1550 -70 { lab=VDD}
N 1770 -120 1770 -70 { lab=VDD}
N 2000 -120 2000 -70 { lab=VDD}
N 2220 -120 2220 -70 { lab=VDD}
N 2440 -120 2440 -70 { lab=VDD}
N 2890 -120 2890 -70 { lab=VDD}
N 2660 -120 2660 -70 { lab=VDD}
N 3110 -120 3110 -70 { lab=VDD}
N 3330 -120 3330 -70 { lab=VDD}
N 890 -50 940 -50 { lab=#net5}
N 1110 -50 1160 -50 { lab=#net6}
N 1330 -50 1380 -50 { lab=#net7}
N 1550 -50 1600 -50 { lab=#net8}
N 2000 -50 2050 -50 { lab=#net9}
N 2220 -50 2270 -50 { lab=#net10}
N 2440 -50 2490 -50 { lab=#net11}
N 2660 -50 2720 -50 { lab=#net12}
N 2890 -50 2940 -50 { lab=#net13}
N 3110 -50 3160 -50 { lab=#net14}
N -230 -50 -170 -50 { lab=#net15}
N -230 -50 -230 90 { lab=#net15}
N -230 90 3420 90 { lab=#net15}
N 0 -30 0 30 { lab=VSS}
N 220 -30 220 30 { lab=VSS}
N 440 -30 440 30 { lab=VSS}
N 670 -30 670 30 { lab=VSS}
N 890 -30 890 30 { lab=VSS}
N 1110 -30 1110 30 { lab=VSS}
N 1330 -30 1330 30 { lab=VSS}
N 1550 -30 1550 30 { lab=VSS}
N 1770 -30 1770 30 { lab=VSS}
N 2000 -30 2000 30 { lab=VSS}
N 2220 -30 2220 30 { lab=VSS}
N 2440 -30 2440 30 { lab=VSS}
N 2660 -30 2660 30 { lab=VSS}
N 2890 -30 2890 30 { lab=VSS}
N 3110 -30 3110 30 { lab=VSS}
N 3330 -30 3330 30 { lab=VSS}
N 3110 30 3330 30 { lab=VSS}
N 2890 30 3110 30 { lab=VSS}
N 2660 30 2890 30 { lab=VSS}
N 2440 30 2660 30 { lab=VSS}
N 2220 30 2440 30 { lab=VSS}
N 2000 30 2220 30 { lab=VSS}
N 1770 30 2000 30 { lab=VSS}
N 1550 30 1770 30 { lab=VSS}
N 1330 30 1550 30 { lab=VSS}
N 1110 30 1330 30 { lab=VSS}
N 890 30 1110 30 { lab=VSS}
N 670 30 890 30 { lab=VSS}
N 440 30 670 30 { lab=VSS}
N 220 30 440 30 { lab=VSS}
N 0 30 220 30 { lab=VSS}
N 0 -120 220 -120 { lab=VDD}
N 220 -120 440 -120 { lab=VDD}
N 440 -120 670 -120 { lab=VDD}
N 670 -120 890 -120 { lab=VDD}
N 890 -120 1110 -120 { lab=VDD}
N 1110 -120 1330 -120 { lab=VDD}
N 1330 -120 1550 -120 { lab=VDD}
N 1550 -120 1770 -120 { lab=VDD}
N 1770 -120 2000 -120 { lab=VDD}
N 2000 -120 2220 -120 { lab=VDD}
N 2220 -120 2440 -120 { lab=VDD}
N 2440 -120 2660 -120 { lab=VDD}
N 2660 -120 2890 -120 { lab=VDD}
N 2890 -120 3110 -120 { lab=VDD}
N 3110 -120 3330 -120 { lab=VDD}
N 2940 -130 3160 -130 { lab=r2}
N 2720 -130 2940 -130 { lab=r2}
N 2490 -130 2720 -130 { lab=r2}
N 2270 -130 2490 -130 { lab=r2}
N 2050 -130 2270 -130 { lab=r2}
N 1830 -130 2050 -130 { lab=r2}
N 1600 -130 1830 -130 { lab=r2}
N 1160 -130 1380 -130 { lab=r1}
N 940 -130 1160 -130 { lab=r1}
N 720 -130 940 -130 { lab=r1}
N 500 -130 720 -130 { lab=r1}
N 270 -130 500 -130 { lab=r1}
N 50 -130 270 -130 { lab=r1}
N -170 -130 50 -130 { lab=r1}
N -170 -130 -170 -70 { lab=r1}
N -170 -30 -170 20 { lab=C1}
N 50 -30 50 20 { lab=C2}
N 270 -30 270 20 { lab=C3}
N 500 -30 500 20 { lab=C4}
N 720 -30 720 20 { lab=C5}
N 940 -30 940 20 { lab=C6}
N 1160 -30 1160 20 { lab=C7}
N 1380 -30 1380 20 { lab=C8}
N 1600 -30 1600 20 { lab=C9}
N 1830 -30 1830 20 { lab=C10}
N 2050 -30 2050 20 { lab=C11}
N 2270 -30 2270 20 { lab=C12}
N 2490 -30 2490 20 { lab=C13}
N 2720 -30 2720 20 { lab=C14}
N 2940 -30 2940 20 { lab=C15}
N 3160 -30 3160 20 { lab=C16}
N 90 -240 180 -240 { lab=VDD}
N 180 -240 180 -120 { lab=VDD}
N 1770 -50 1840 -50 { lab=#net16}
N 3590 -50 3640 -50 { lab=#net17}
N 3590 -120 3590 -70 { lab=VDD}
N 3810 -120 3810 -70 { lab=VDD}
N 3860 -130 3860 -70 { lab=r3}
N 3810 -50 3860 -50 { lab=#net18}
N 4030 -120 4030 -70 { lab=VDD}
N 4030 -50 4090 -50 { lab=#net19}
N 4260 -120 4260 -70 { lab=VDD}
N 4260 -50 4310 -50 { lab=#net20}
N 4310 -130 4310 -70 { lab=r3}
N 3640 -130 3640 -70 { lab=r3}
N 4090 -130 4090 -70 { lab=r3}
N 4530 -130 4530 -70 { lab=r3}
N 4750 -130 4750 -70 { lab=r3}
N 4970 -130 4970 -70 { lab=r3}
N 5190 -130 5190 -70 { lab=r4}
N 5420 -130 5420 -70 { lab=r4}
N 5640 -130 5640 -70 { lab=r4}
N 5860 -130 5860 -70 { lab=r4}
N 6080 -130 6080 -70 { lab=r4}
N 6310 -130 6310 -70 { lab=r4}
N 6530 -130 6530 -70 { lab=r4}
N 6750 -130 6750 -70 { lab=r4}
N 3860 -130 3860 -70 { lab=r3}
N 4480 -120 4480 -70 { lab=VDD}
N 4700 -120 4700 -70 { lab=VDD}
N 4920 -120 4920 -70 { lab=VDD}
N 5140 -120 5140 -70 { lab=VDD}
N 5360 -120 5360 -70 { lab=VDD}
N 5590 -120 5590 -70 { lab=VDD}
N 5810 -120 5810 -70 { lab=VDD}
N 6030 -120 6030 -70 { lab=VDD}
N 6480 -120 6480 -70 { lab=VDD}
N 6250 -120 6250 -70 { lab=VDD}
N 6700 -120 6700 -70 { lab=VDD}
N 6920 -120 6920 -70 { lab=VDD}
N 4480 -50 4530 -50 { lab=#net21}
N 4700 -50 4750 -50 { lab=#net22}
N 4920 -50 4970 -50 { lab=#net23}
N 5140 -50 5190 -50 { lab=#net24}
N 5590 -50 5640 -50 { lab=#net25}
N 5810 -50 5860 -50 { lab=#net26}
N 6030 -50 6080 -50 { lab=#net27}
N 6250 -50 6310 -50 { lab=#net28}
N 6480 -50 6530 -50 { lab=#net29}
N 6700 -50 6750 -50 { lab=#net30}
N 6920 -50 7010 -50 { lab=#net15}
N 3360 90 7010 90 { lab=#net15}
N 7010 -50 7010 90 { lab=#net15}
N 3590 -30 3590 30 { lab=VSS}
N 3810 -30 3810 30 { lab=VSS}
N 4030 -30 4030 30 { lab=VSS}
N 4260 -30 4260 30 { lab=VSS}
N 4480 -30 4480 30 { lab=VSS}
N 4700 -30 4700 30 { lab=VSS}
N 4920 -30 4920 30 { lab=VSS}
N 5140 -30 5140 30 { lab=VSS}
N 5360 -30 5360 30 { lab=VSS}
N 5590 -30 5590 30 { lab=VSS}
N 5810 -30 5810 30 { lab=VSS}
N 6030 -30 6030 30 { lab=VSS}
N 6250 -30 6250 30 { lab=VSS}
N 6480 -30 6480 30 { lab=VSS}
N 6700 -30 6700 30 { lab=VSS}
N 6920 -30 6920 30 { lab=VSS}
N 6700 30 6920 30 { lab=VSS}
N 6480 30 6700 30 { lab=VSS}
N 6250 30 6480 30 { lab=VSS}
N 6030 30 6250 30 { lab=VSS}
N 5810 30 6030 30 { lab=VSS}
N 5590 30 5810 30 { lab=VSS}
N 5360 30 5590 30 { lab=VSS}
N 5140 30 5360 30 { lab=VSS}
N 4920 30 5140 30 { lab=VSS}
N 4700 30 4920 30 { lab=VSS}
N 4480 30 4700 30 { lab=VSS}
N 4260 30 4480 30 { lab=VSS}
N 4030 30 4260 30 { lab=VSS}
N 3810 30 4030 30 { lab=VSS}
N 3590 30 3810 30 { lab=VSS}
N 3590 -120 3810 -120 { lab=VDD}
N 3810 -120 4030 -120 { lab=VDD}
N 4030 -120 4260 -120 { lab=VDD}
N 4260 -120 4480 -120 { lab=VDD}
N 4480 -120 4700 -120 { lab=VDD}
N 4700 -120 4920 -120 { lab=VDD}
N 4920 -120 5140 -120 { lab=VDD}
N 5140 -120 5360 -120 { lab=VDD}
N 5360 -120 5590 -120 { lab=VDD}
N 5590 -120 5810 -120 { lab=VDD}
N 5810 -120 6030 -120 { lab=VDD}
N 6030 -120 6250 -120 { lab=VDD}
N 6250 -120 6480 -120 { lab=VDD}
N 6480 -120 6700 -120 { lab=VDD}
N 6700 -120 6920 -120 { lab=VDD}
N 6530 -130 6750 -130 { lab=r4}
N 6310 -130 6530 -130 { lab=r4}
N 6080 -130 6310 -130 { lab=r4}
N 5860 -130 6080 -130 { lab=r4}
N 5640 -130 5860 -130 { lab=r4}
N 5420 -130 5640 -130 { lab=r4}
N 5190 -130 5420 -130 { lab=r4}
N 4750 -130 4970 -130 { lab=r3}
N 4530 -130 4750 -130 { lab=r3}
N 4310 -130 4530 -130 { lab=r3}
N 4090 -130 4310 -130 { lab=r3}
N 3860 -130 4090 -130 { lab=r3}
N 3640 -130 3860 -130 { lab=r3}
N 3420 -130 3640 -130 { lab=r3}
N 3420 -130 3420 -70 { lab=r3}
N 3420 -30 3420 20 { lab=C17}
N 3640 -30 3640 20 { lab=C18}
N 3860 -30 3860 20 { lab=C19}
N 4090 -30 4090 20 { lab=C20}
N 4310 -30 4310 20 { lab=C21}
N 4530 -30 4530 20 { lab=C22}
N 4750 -30 4750 20 { lab=C23}
N 4970 -30 4970 20 { lab=C24}
N 5190 -30 5190 20 { lab=C25}
N 5420 -30 5420 20 { lab=C26}
N 5640 -30 5640 20 { lab=C27}
N 5860 -30 5860 20 { lab=C28}
N 6080 -30 6080 20 { lab=C29}
N 6310 -30 6310 20 { lab=C30}
N 6530 -30 6530 20 { lab=C31}
N 6750 -30 6750 20 { lab=C32}
N 5360 -50 5430 -50 { lab=#net31}
N 3330 30 3630 30 { lab=VSS}
N 3330 -50 3430 -50 { lab=#net32}
N 3330 -120 3620 -120 { lab=VDD}
N -560 -400 -490 -400 { lab=VDD}
N -560 -350 -490 -350 { lab=VSS}
N -170 -530 -90 -530 { lab=#net33}
N -10 -610 -10 -530 { lab=#net34}
N -10 -610 80 -610 { lab=#net34}
N -10 -530 -10 -470 { lab=#net34}
N -10 -470 80 -470 { lab=#net34}
N 160 -670 160 -610 { lab=#net35}
N 160 -670 240 -670 { lab=#net35}
N 160 -610 160 -590 { lab=#net35}
N 160 -590 240 -590 { lab=#net35}
N 160 -510 160 -470 { lab=#net36}
N 160 -510 240 -510 { lab=#net36}
N 160 -470 160 -430 { lab=#net36}
N 160 -430 240 -430 { lab=#net36}
N 320 -670 370 -670 { lab=r1}
N 320 -590 360 -590 { lab=r2}
N 320 -510 360 -510 { lab=r3}
N 320 -430 370 -430 { lab=r4}
N -310 -530 -250 -530 { lab=RESET}
N -1020 30 -900 30 { lab=C9}
N -1020 70 -900 70 { lab=C10}
N -1020 110 -900 110 { lab=C11}
N -1020 160 -900 160 { lab=C12}
N -1020 200 -900 200 { lab=C13}
N -1020 240 -900 240 { lab=C14}
N -1020 280 -900 280 { lab=C15}
N -1020 320 -900 320 { lab=C16}
N -790 30 -670 30 { lab=C17}
N -790 70 -670 70 { lab=C18}
N -790 110 -670 110 { lab=C19}
N -790 160 -670 160 { lab=C20}
N -790 200 -670 200 { lab=C21}
N -790 240 -670 240 { lab=C22}
N -790 280 -670 280 { lab=C23}
N -790 320 -670 320 { lab=C24}
N -580 30 -460 30 { lab=C25}
N -580 70 -460 70 { lab=C26}
N -580 110 -460 110 { lab=C27}
N -580 160 -460 160 { lab=C28}
N -580 200 -460 200 { lab=C29}
N -580 240 -460 240 { lab=C30}
N -580 280 -460 280 { lab=C31}
N -580 320 -460 320 { lab=C32}
N -1220 30 -1100 30 { lab=C1}
N -1220 70 -1100 70 { lab=C2}
N -1220 110 -1100 110 { lab=C3}
N -1220 160 -1100 160 { lab=C4}
N -1220 200 -1100 200 { lab=C5}
N -1220 240 -1100 240 { lab=C6}
N -1220 280 -1100 280 { lab=C7}
N -1220 320 -1100 320 { lab=C8}
N -330 -750 -270 -750 { lab=RESET}
N -270 -750 -170 -750 { lab=RESET}
N 6840 -10 6860 -10 { lab=OUT}
N 6860 -10 6860 170 { lab=OUT}
N 6860 170 6870 170 { lab=OUT}
N 6620 -10 6650 -10 { lab=#net37}
N 6400 -10 6420 -10 { lab=#net38}
N 6170 -10 6200 -10 { lab=#net39}
N 5950 -10 5990 -10 { lab=#net40}
N 5730 -10 5770 -10 { lab=#net41}
N 5510 -10 5550 -10 { lab=#net42}
N 5280 -10 5320 -10 { lab=#net43}
N 5060 -10 5100 -10 { lab=#net44}
N 4840 -10 4880 -10 { lab=#net45}
N 4620 -10 4650 -10 { lab=#net46}
N 4400 -10 4430 -10 { lab=#net47}
N 4180 -10 4230 -10 { lab=#net48}
N 3950 -10 3980 -10 { lab=#net49}
N 3730 -10 3770 -10 { lab=#net50}
N 3510 -10 3550 -10 { lab=#net51}
N 3250 -10 3290 -10 { lab=#net52}
N 3030 -10 3060 -10 { lab=#net53}
N 2810 -10 2840 -10 { lab=#net54}
N 2580 -10 2620 -10 { lab=#net55}
N 2360 -10 2420 -10 { lab=#net56}
N 2140 -10 2180 -10 { lab=#net57}
N 1920 -10 1960 -10 { lab=#net58}
N 1690 -10 1740 -10 { lab=#net59}
N 1470 -10 1500 -10 { lab=#net60}
N 1250 -10 1280 -10 { lab=#net61}
N 1030 -10 1060 -10 { lab=#net62}
N 810 -10 840 -10 { lab=#net63}
N 590 -10 640 -10 { lab=#net64}
N 360 -10 390 -10 { lab=#net65}
N 140 -10 180 -10 { lab=#net66}
N -80 -10 -30 -10 { lab=#net67}
C {singlestage.sym} -20 -50 0 0 {name=x1}
C {singlestage.sym} 200 -50 0 0 {name=x2}
C {singlestage.sym} 420 -50 0 0 {name=x3}
C {singlestage.sym} 650 -50 0 0 {name=x4}
C {singlestage.sym} 870 -50 0 0 {name=x5}
C {singlestage.sym} 1090 -50 0 0 {name=x6}
C {singlestage.sym} 1310 -50 0 0 {name=x7}
C {singlestage.sym} 1530 -50 0 0 {name=x8}
C {singlestage.sym} 2640 -50 0 0 {name=x13}
C {singlestage.sym} 2870 -50 0 0 {name=x14}
C {singlestage.sym} 3090 -50 0 0 {name=x15}
C {singlestage.sym} 3310 -50 0 0 {name=x16}
C {singlestage.sym} 1750 -50 0 0 {name=x17}
C {singlestage.sym} 1980 -50 0 0 {name=x18}
C {singlestage.sym} 2200 -50 0 0 {name=x19}
C {singlestage.sym} 2420 -50 0 0 {name=x20}
C {devices/lab_pin.sym} 3160 0 0 0 {name=l7 sig_type=std_logic lab=C16}
C {devices/lab_pin.sym} 2940 0 0 0 {name=l8 sig_type=std_logic lab=C15}
C {devices/lab_pin.sym} 2720 0 0 0 {name=l9 sig_type=std_logic lab=C14}
C {devices/lab_pin.sym} 2490 0 0 0 {name=l11 sig_type=std_logic lab=C13}
C {devices/lab_pin.sym} 2270 0 0 0 {name=l12 sig_type=std_logic lab=C12}
C {devices/lab_pin.sym} 2050 0 0 0 {name=l13 sig_type=std_logic lab=C11}
C {devices/lab_pin.sym} 1830 0 0 0 {name=l14 sig_type=std_logic lab=C10}
C {devices/lab_pin.sym} 1600 0 0 0 {name=l15 sig_type=std_logic lab=C9}
C {devices/lab_pin.sym} 140 -240 0 0 {name=l24 sig_type=std_logic lab=VDD}
C {singlestage.sym} 3570 -50 0 0 {name=x21}
C {singlestage.sym} 3790 -50 0 0 {name=x22}
C {singlestage.sym} 4010 -50 0 0 {name=x23}
C {singlestage.sym} 4240 -50 0 0 {name=x24}
C {singlestage.sym} 4460 -50 0 0 {name=x25}
C {singlestage.sym} 4680 -50 0 0 {name=x26}
C {singlestage.sym} 4900 -50 0 0 {name=x27}
C {singlestage.sym} 5120 -50 0 0 {name=x28}
C {singlestage.sym} 6230 -50 0 0 {name=x33}
C {singlestage.sym} 6460 -50 0 0 {name=x34}
C {singlestage.sym} 6680 -50 0 0 {name=x35}
C {singlestage.sym} 6900 -50 0 0 {name=x36}
C {singlestage.sym} 5340 -50 0 0 {name=x37}
C {singlestage.sym} 5570 -50 0 0 {name=x38}
C {singlestage.sym} 5790 -50 0 0 {name=x39}
C {singlestage.sym} 6010 -50 0 0 {name=x40}
C {devices/lab_pin.sym} 6750 0 0 0 {name=l29 sig_type=std_logic lab=C32}
C {devices/lab_pin.sym} 6530 0 0 0 {name=l30 sig_type=std_logic lab=C31}
C {devices/lab_pin.sym} 6310 0 0 0 {name=l31 sig_type=std_logic lab=C30}
C {devices/lab_pin.sym} 6080 0 0 0 {name=l32 sig_type=std_logic lab=C29}
C {devices/lab_pin.sym} 5860 0 0 0 {name=l33 sig_type=std_logic lab=C28}
C {devices/lab_pin.sym} 5640 0 0 0 {name=l34 sig_type=std_logic lab=C27}
C {devices/lab_pin.sym} 5420 0 0 0 {name=l35 sig_type=std_logic lab=C26}
C {devices/lab_pin.sym} 5190 0 0 0 {name=l36 sig_type=std_logic lab=C25}
C {devices/lab_pin.sym} 4970 0 0 0 {name=l37 sig_type=std_logic lab=C24}
C {devices/lab_pin.sym} 4750 0 0 0 {name=l38 sig_type=std_logic lab=C23
}
C {devices/lab_pin.sym} 4530 0 0 0 {name=l39 sig_type=std_logic lab=C22}
C {devices/lab_pin.sym} 4310 0 0 0 {name=l40 sig_type=std_logic lab=C21}
C {devices/lab_pin.sym} 4090 0 0 0 {name=l41 sig_type=std_logic lab=C20}
C {devices/lab_pin.sym} 3860 0 0 0 {name=l42 sig_type=std_logic lab=C19
}
C {devices/lab_pin.sym} 3640 0 0 0 {name=l43 sig_type=std_logic lab=C18}
C {devices/lab_pin.sym} 3420 0 0 0 {name=l44 sig_type=std_logic lab=C17}
C {devices/iopin.sym} -500 -400 0 0 {name=p1 lab=VDD}
C {devices/lab_pin.sym} -530 -400 0 0 {name=l23 sig_type=std_logic lab=VDD}
C {devices/iopin.sym} -500 -350 0 0 {name=p2 lab=VSS}
C {devices/lab_pin.sym} -530 -350 0 0 {name=l27 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 6860 170 0 0 {name=p3 lab=OUT}
C {devices/lab_pin.sym} 40 30 0 0 {name=l1 sig_type=std_logic lab=VSS}
C {sky130_stdcells/inv_1.sym} -210 -530 0 0 {name=x42 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_4.sym} -50 -530 0 0 {name=x43 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_8.sym} 120 -610 0 0 {name=x44 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_8.sym} 120 -470 0 0 {name=x45 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_16.sym} 280 -590 0 0 {name=x47 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_16.sym} 280 -670 0 0 {name=x48 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_16.sym} 280 -430 0 0 {name=x50 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_16.sym} 280 -510 0 0 {name=x51 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} -300 -530 0 0 {name=l2 sig_type=std_logic lab=RESET}
C {devices/lab_pin.sym} -80 -130 0 0 {name=l25 sig_type=std_logic lab=r1}
C {devices/lab_pin.sym} 1720 -130 0 0 {name=l26 sig_type=std_logic lab=r2}
C {devices/lab_pin.sym} 3540 -130 0 0 {name=l28 sig_type=std_logic lab=r3}
C {devices/lab_pin.sym} 5290 -130 0 0 {name=l45 sig_type=std_logic lab=r4}
C {devices/lab_pin.sym} -170 0 0 0 {name=l5 sig_type=std_logic lab=C1}
C {devices/lab_pin.sym} 50 0 0 0 {name=l10 sig_type=std_logic lab=C2}
C {devices/lab_pin.sym} 270 0 0 0 {name=l16 sig_type=std_logic lab=C3
}
C {devices/lab_pin.sym} 500 0 0 0 {name=l18 sig_type=std_logic lab=C4}
C {devices/lab_pin.sym} 720 0 0 0 {name=l19 sig_type=std_logic lab=C5}
C {devices/lab_pin.sym} 940 0 0 0 {name=l20 sig_type=std_logic lab=C6}
C {devices/lab_pin.sym} 1160 0 0 0 {name=l21 sig_type=std_logic lab=C7}
C {devices/lab_pin.sym} 1380 0 0 0 {name=l22 sig_type=std_logic lab=C8}
C {devices/lab_pin.sym} -170 0 0 0 {name=l46 sig_type=std_logic lab=C1}
C {devices/ipin.sym} -1010 30 0 0 {name=p4 lab=C9}
C {devices/lab_pin.sym} -930 30 0 0 {name=l47 sig_type=std_logic lab=C9}
C {devices/ipin.sym} -1010 70 0 0 {name=p5 lab=C10}
C {devices/lab_pin.sym} -930 70 0 0 {name=l48 sig_type=std_logic lab=C10}
C {devices/ipin.sym} -1010 110 0 0 {name=p6 lab=C11}
C {devices/lab_pin.sym} -930 110 0 0 {name=l49 sig_type=std_logic lab=C11}
C {devices/ipin.sym} -1010 160 0 0 {name=p7 lab=C12}
C {devices/lab_pin.sym} -930 160 0 0 {name=l50 sig_type=std_logic lab=C12}
C {devices/ipin.sym} -1010 200 0 0 {name=p8 lab=C13}
C {devices/lab_pin.sym} -930 200 0 0 {name=l51 sig_type=std_logic lab=C13}
C {devices/ipin.sym} -1010 240 0 0 {name=p9 lab=C14}
C {devices/lab_pin.sym} -930 240 0 0 {name=l52 sig_type=std_logic lab=C14}
C {devices/ipin.sym} -1010 280 0 0 {name=p10 lab=C15}
C {devices/lab_pin.sym} -930 280 0 0 {name=l53 sig_type=std_logic lab=C15}
C {devices/ipin.sym} -1010 320 0 0 {name=p11 lab=C16}
C {devices/lab_pin.sym} -930 320 0 0 {name=l54 sig_type=std_logic lab=C16}
C {devices/ipin.sym} -780 30 0 0 {name=p12 lab=C17}
C {devices/lab_pin.sym} -700 30 0 0 {name=l55 sig_type=std_logic lab=C17}
C {devices/ipin.sym} -780 70 0 0 {name=p13 lab=C18}
C {devices/lab_pin.sym} -700 70 0 0 {name=l56 sig_type=std_logic lab=C18}
C {devices/ipin.sym} -780 110 0 0 {name=p14 lab=C19}
C {devices/lab_pin.sym} -700 110 0 0 {name=l57 sig_type=std_logic lab=C19}
C {devices/ipin.sym} -780 160 0 0 {name=p15 lab=C20}
C {devices/lab_pin.sym} -700 160 0 0 {name=l58 sig_type=std_logic lab=C20}
C {devices/ipin.sym} -780 200 0 0 {name=p16 lab=C21}
C {devices/lab_pin.sym} -700 200 0 0 {name=l59 sig_type=std_logic lab=C21}
C {devices/ipin.sym} -780 240 0 0 {name=p17 lab=C22}
C {devices/lab_pin.sym} -700 240 0 0 {name=l60 sig_type=std_logic lab=C22}
C {devices/ipin.sym} -780 280 0 0 {name=p18 lab=C23}
C {devices/lab_pin.sym} -700 280 0 0 {name=l61 sig_type=std_logic lab=C23}
C {devices/ipin.sym} -780 320 0 0 {name=p19 lab=C24}
C {devices/lab_pin.sym} -700 320 0 0 {name=l62 sig_type=std_logic lab=C24}
C {devices/ipin.sym} -570 30 0 0 {name=p20 lab=C25}
C {devices/lab_pin.sym} -490 30 0 0 {name=l63 sig_type=std_logic lab=C25}
C {devices/ipin.sym} -570 70 0 0 {name=p21 lab=C26}
C {devices/lab_pin.sym} -490 70 0 0 {name=l64 sig_type=std_logic lab=C26}
C {devices/ipin.sym} -570 110 0 0 {name=p22 lab=C27}
C {devices/lab_pin.sym} -490 110 0 0 {name=l65 sig_type=std_logic lab=C27}
C {devices/ipin.sym} -570 160 0 0 {name=p23 lab=C28}
C {devices/lab_pin.sym} -490 160 0 0 {name=l66 sig_type=std_logic lab=C28}
C {devices/ipin.sym} -570 200 0 0 {name=p24 lab=C29}
C {devices/lab_pin.sym} -490 200 0 0 {name=l67 sig_type=std_logic lab=C29}
C {devices/ipin.sym} -570 240 0 0 {name=p25 lab=C30}
C {devices/lab_pin.sym} -490 240 0 0 {name=l68 sig_type=std_logic lab=C30}
C {devices/ipin.sym} -570 280 0 0 {name=p26 lab=C31}
C {devices/lab_pin.sym} -490 280 0 0 {name=l69 sig_type=std_logic lab=C31}
C {devices/ipin.sym} -570 320 0 0 {name=p27 lab=C32}
C {devices/lab_pin.sym} -490 320 0 0 {name=l70 sig_type=std_logic lab=C32}
C {devices/ipin.sym} -1210 30 0 0 {name=p28 lab=C1}
C {devices/lab_pin.sym} -1130 30 0 0 {name=l71 sig_type=std_logic lab=C1}
C {devices/ipin.sym} -1210 70 0 0 {name=p29 lab=C2}
C {devices/lab_pin.sym} -1130 70 0 0 {name=l72 sig_type=std_logic lab=C2}
C {devices/ipin.sym} -1210 110 0 0 {name=p30 lab=C3}
C {devices/lab_pin.sym} -1130 110 0 0 {name=l73 sig_type=std_logic lab=C3}
C {devices/ipin.sym} -1210 160 0 0 {name=p31 lab=C4}
C {devices/lab_pin.sym} -1130 160 0 0 {name=l74 sig_type=std_logic lab=C4}
C {devices/ipin.sym} -1210 200 0 0 {name=p32 lab=C5}
C {devices/lab_pin.sym} -1130 200 0 0 {name=l75 sig_type=std_logic lab=C5}
C {devices/ipin.sym} -1210 240 0 0 {name=p33 lab=C6}
C {devices/lab_pin.sym} -1130 240 0 0 {name=l76 sig_type=std_logic lab=C6}
C {devices/ipin.sym} -1210 280 0 0 {name=p34 lab=C7}
C {devices/lab_pin.sym} -1130 280 0 0 {name=l77 sig_type=std_logic lab=C7}
C {devices/ipin.sym} -1210 320 0 0 {name=p35 lab=C8}
C {devices/lab_pin.sym} -1130 320 0 0 {name=l78 sig_type=std_logic lab=C8}
C {devices/ipin.sym} -320 -750 0 0 {name=p36 lab=RESET}
C {devices/lab_pin.sym} -230 -750 0 0 {name=l79 sig_type=std_logic lab=RESET}
C {devices/lab_pin.sym} 360 -670 0 0 {name=l3 sig_type=std_logic lab=r1}
C {devices/lab_pin.sym} 350 -590 0 0 {name=l4 sig_type=std_logic lab=r2}
C {devices/lab_pin.sym} 350 -510 0 0 {name=l6 sig_type=std_logic lab=r3}
C {devices/lab_pin.sym} 350 -430 0 0 {name=l17 sig_type=std_logic lab=r4}
